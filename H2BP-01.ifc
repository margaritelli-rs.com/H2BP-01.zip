Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 1b5e5e3c-d1a3-438c-93ba-32c8b28e05e7, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: H2BP-01.ifc
Time: 2025-10-19T12:55:28+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: H2BP-01_R23:H2BP-01_R23, H2BP-01_R23:H2BP-01_R23:20535
In: Livello 1
Type - Material: <Unnamed>, Metal, wood, Steel
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: H2BP-01_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza lama (cm): 84; altezza tot (cm): 110; ASI: 1,2; CAD layer: n.a.; certificato art 14 comma 22: TOCUSTOMIZE; certificato CE: TOCUSTOMIZE; certificato di corretta posa: TOCUSTOMIZE; classe: H2; classe intrusione del veicolo: VI5; classe larghezza di lavoro: W5; cordolo: rialzato 125 mm; deflessione dinamica (m): 1; documentazione integrativa (url): TOCUSTOMIZE; DOP: TOCUSTOMIZE; DSM: n.a.; EPD: sì; GWP totale cradle to gate: 24,29 kgCO2eq/m; infissione (m): n.a.; interasse (m): 2; intrusione del veicolo (m): 1,4; larghezza di lavoro (m): 1,5; larghezza max (cm): 37; lavorazione aggiuntiva: TOCUSTOMIZE; Legno CAM Strade: CoC PEFC; livello di severità: B; lunghezza minima (m): 80; manuale di installazione: TOCUSTOMIZE; materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: H2BP-01; N° certificato CE: CPR/0491/3153; Nome del tipo: H2BP-01_R23; norma di riferimento: EN 1317-2 e EN1317-5; prezzo di capitolato: 334; prodotto: Barriera di sicurezza stradale; Produttore: Margaritelli Road Safety; progressiva finale: TOCUSTOMIZE; progressiva iniziale: TOCUSTOMIZE; resoconti di prova: TOCUSTOMIZE; supporto: fondazione cls; testata su arginello: n.a.; tipologia: H2 Bordo Ponte; unità di misura: m; URL: https://margaritelli-rs.com/it/products/h2bp-01/; url (certificati CE, DOP, manuali, schede tecniche, schemi): https://margaritelli-rs.com/it/products/h2bp-01/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: H2BP-01_R23
Pset_RailingCommon - Reference: H2BP-01_R23; IsExternal: no
Altro - Basement: yes; Bordo_Dx: yes; Bordo_Sx: yes; Famiglia: H2BP-01_R23; Famiglia e tipo: H2BP-01_R23: H2BP-01_R23; ID tipo: 20519; Tipo: H2BP-01_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 12.6984 m2; Volume: 0.729642 m3
